# Keil uVision project adc.uvproj, settings and files
target adc (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: QN9020 NXP
  cpu: IRAM(0x00008000-0x0000FFFF) IROM(0x00000000-0x00007FFF) CLOCK(16000000) CPUTYPE("Cortex-M0")
  output: adc
  AfterMake: fromelf --bin --output ./bin/adc.bin ./obj/adc.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c misc: --C99
  c include: ..\src;..\..\src\driver;..\..\src\fw;..\..\src\cmsis;..\..\src\lib
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  scatter file: ..\..\src\link\keil\qn9020_link.sct
  group startup
    ../../src/startup/keil/: startup.s
  group system
    ../src/: system.c
  group driver
    ../../src/driver/: adc.c analog.c dma.c gpio.c i2c.c pwm.c rtc.c serialflash.c sleep.c spi.c syscon.c timer.c uart.c wdt.c
  group lib
    ../../src/lib/keil/: qn902xb2_lib_lite.lib
  group retarget
    ../../src/retarget/: retarget.c
  group main
    ../src/: adc_example.c
